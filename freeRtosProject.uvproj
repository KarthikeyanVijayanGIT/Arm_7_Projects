# Keil uVision project freeRtosProject.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: freeRtosProject +hex
  c flags: Optim=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: ..\..\reference\freeRtos\FreeRTOS_V9.0.0rc2\FreeRTOS\Demo\Common\include;..\..\reference\freeRtos\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;..\..\reference\freeRtos\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\include;.
  asm include: ..\..\reference\freeRtos\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c
    ../../../FreeRTOSv202012.00/FreeRTOSv202012.00/FreeRTOS/Source/: timers.c
    ../../reference/freeRtos/FreeRTOS_V9.0.0rc2/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../reference/freeRtos/FreeRTOS_V9.0.0rc2/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    ../../reference/freeRtos/FreeRTOS_V9.0.0rc2/FreeRTOS/Source/portable/MemMang/: heap_2.c
